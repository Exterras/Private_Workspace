<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC_.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC_Converter\DC_Converter_IAR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_test01.ewp</path>
  </project>
  <batchBuild/>
</workspace>


